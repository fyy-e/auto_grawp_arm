Commit message: 实现基本的机械臂手眼定位

File: src/urdf/urdf/DM_urdf.urdf (robot description, URDF)
Before this commit: robot DM_urdf, 7 links, 6 joints
Joints:
- joint joint_1: axis 0 0 -1 -> 0 0 1
- joint joint_4: axis 0 0 -1 -> 0 0 1
- joint joint_5: axis 0 0 -1 -> 0 0 1
